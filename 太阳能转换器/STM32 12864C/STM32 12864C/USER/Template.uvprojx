# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\W25QXX;..\HARDWARE\SPI;..\HARDWARE\IIC;..\HARDWARE\ds3231;..\PROGRAM\clock;..\HARDWARE\ADC;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\MALLOC;..\HARDWARE\ST7565R;..\HARDWARE\24C02;..\HARDWARE\TIMER;..\HARDWARE\LED;..\HARDWARE\TEXT;..\PROGRAM\menu;..\HARDWARE\ADC;..\PROGRAM\nongli;..\HARDWARE\dht11;..\HARDWARE\EXTI;..\HARDWARE\INA226;..\HARDWARE\CW2015
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s core_cm3.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group HARDWARE
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/ds3231/: ds3231.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/24C02/: 24c02.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TEXT/: text.c fontupd.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/dht11/: dht11.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/CW2015/: cw2015.c
    ../HARDWARE/INA226/: ina226.c
  group PROGRAM
    ../PROGRAM/clock/: clock.c
    ../PROGRAM/menu/: menu.c
    ../PROGRAM/nongli/: nongliSTM.c
  group ST7565R
    ../HARDWARE/ST7565R/: ST7565.C
